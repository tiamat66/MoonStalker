# Repository tiamat66/MoonStalker

File README.md:

# MoonStalker

**Software for GoTo telescope control**

## Purpose

Project for GoTo telescope control consists of hardware and software. Software lives in this repository. There are two pieces of software.
 
The first called Drive is used on an arduino based platform that drives the hardwares GoTo feature and uses stepper motors.

The second piece called Control is Android based software that commands the Drive software and contains the user interface and logic.

## KiCad design Hardware/PCB/MoonStalker.kicad_pcb

Parts:
C1, C6, C10: 47nF; C_Rect_L13_W4_P10
C2, C3: 220uF; C_Radial_D10_L13_P5
C4, C5: 100nF; C_Rect_L7_W2.5_P5
C7, C8: 1000uF; C_Radial_D10_L16_P5
C9: 47nF; C_Rect_L10_W2.5_P7.5
P1, P2, P3, P4, P5: CONN_01X02; TerminalBlock_Pheonix_MPT-2.54mm_2pol
R1: 3k3; Resistor_Horizontal_RM7mm
R2: 1k; Resistor_Horizontal_RM7mm
U1, U2: Pololu_DRV8825
U3: TEL3-1211
U4: Arduino_Micro
U5: HC-05_Bluetooth_Radio; Socket_Strip_Straight_1x06

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, P1.1, R2.2, U1.1 (~ENABLE), U1.2 (M0), U1.3 (M1), U1.4 (M2), U1.9 (GND), U1.15 (GND), U2.1 (~ENABLE), U2.2 (M0), U2.3 (M1), U2.4 (M2), U2.9 (GND), U2.15 (GND), U3.10 (-Vout), U3.12 (-Vin(GND)), U3.13 (-Vin(GND)), U3.15 (-Vout), U4.6 (GND), U4.31 (GND), U5.3 (GND)
HORIZ_DIR: U1.8 (DIR), U4.8 (3(PWM)/SCL)
HORIZ_FAULT: U1.10 (~FAULT), U4.16 (11(PWM))
HORIZ_RESET: U1.5 (~RESET), U4.12 (7)
HORIZ_SLEEP: U1.6 (~SLEEP), U4.13 (8/A8)
HORIZ_STEP: U1.7 (STEP), U4.7 (2/SDA)
unnamed: P2.1, U1.14 (B2)
unnamed: P2.2, U1.13 (B1)
unnamed: P3.1, U1.12 (A1)
unnamed: P3.2, U1.11 (A2)
unnamed: P4.1, U2.14 (B2)
unnamed: P4.2, U2.13 (B1)
unnamed: P5.1, U2.12 (A1)
unnamed: P5.2, U2.11 (A2)
RXD: U4.3 (1/TX), U5.5 (RXD)
TXD: U4.4 (0/RX), U5.4 (TXD)
VAA: C1.1, C2.1, C3.1, C4.1, C5.1, C7.1, P1.2, R1.1, U1.16 (VMOT), U2.16 (VMOT), U3.1 (+Vin(VCC)), U3.24 (+Vin(VCC))
VBATT: R1.2, R2.1, U4.21 (A0)
VCC: C6.1, C8.1, C9.1, C10.1, U3.11 (+Vout), U3.14 (+Vout), U4.5 (RESET), U4.29 (+5V), U4.30 (RESET), U5.2 (VCC)
VERT_DIR: U2.8 (DIR), U4.11 (6(PWM)/A7)
VERT_FAULT: U2.10 (~FAULT), U4.17 (12/A11)
VERT_RESET: U2.5 (~RESET), U4.14 (9(PWM)/A9)
VERT_SLEEP: U2.6 (~SLEEP), U4.15 (10(PWM)/A10)
VERT_STEP: U2.7 (STEP), U4.10 (5(PWM))

Notes on the sheet:
HORIZONTAL DRIVER
VERTICAL DRIVER

Board: 2 copper layers, 91.4 x 86.4 mm, 22 parts (0 on the bottom side), 24 nets.

## Code that names these connections

File Hardware/ArduinoSW/MoonStalker/MoonStalker.ino:

// MoonStalker control software
//
// This software controls custom MoonStalker hardware, that
// in turn drives the stepper motors that turn the telescope.
// Arduino Micro is used as the main board.

// pin numbers
const char RXD         = 3;
const char TXD         = 4;
const char HORIZ_STEP  = 7;
const char HORIZ_DIR   = 8;
const char VERT_STEP   = 10;
const char VERT_DIR    = 11;
const char HORIZ_RESET = 12;
const char HORIZ_SLEEP = 13;
const char VERT_RESET  = 14;
const char VERT_SLEEP  = 15;
const char HORIZ_FAULT = 16;
const char VERT_FAULT  = 17;
const char VBATT       = 21;

// serial speed
const int SERIAL_SPEED = 115200;

// initialize pins
// Set the direction of the pins,
// setup everything else
void initialize_pins() {
    const char unused_pins[] = {9, 22, 23, 24, 25, 26};

    // Set digital pins as input and output
    pinMode(RXD, OUTPUT);
    pinMode(TXD, INPUT);
    pinMode(HORIZ_STEP, OUTPUT);
    pinMode(HORIZ_DIR, OUTPUT);
    pinMode(VERT_STEP, OUTPUT);
    pinMode(VERT_DIR, OUTPUT);
    pinMode(HORIZ_RESET, OUTPUT);
    pinMode(HORIZ_SLEEP, OUTPUT);
    pinMode(VERT_RESET, OUTPUT);
    pinMode(VERT_SLEEP, OUTPUT);
    pinMode(HORIZ_FAULT, INPUT);
    pinMode(VERT_FAULT, INPUT);
    // Set unconnected pins as internal pullup
    for (int i; i < sizeof(unused_pins); i++) {
        pinMode(unused_pins[i], INTERNAP_PULLUP);
    }
}

// Setup the board at the start
void setup() {
    Serial1.begin(SERIAL_SPEED);
    initialize_pins();
}

// Main processor loop
void loop() {
    serial_message_processor();

}

## Commit log (part)

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2015-01-21 Update README file with initial information.
2015-01-21 Added directories for Control and Drive together with small readme files
2015-01-21 Added documentation directory
2015-01-21 Changed readme a bit
2015-02-25 An example for how to drive the motor simply
2015-04-15 Added tinycad library for arduino micro
2015-06-15 Added new symbol for DRV8825 and pdf. Added dsn for kozaskop
2015-06-17 Created more custom parts in tinycad and more schematic completed
2015-12-29 Created hardware and software directories
2015-12-29 Added a new kicad project for pcb
2016-01-04 Changed to new name MoonStalker
2016-01-05 Deleted Hardware
2016-01-06 Started creating kicad schematic, created arduino and pololu drv stepper driver parts
2016-01-07 Added components for DCDC converter and BlueTooth radio
2016-01-10 Added a few more connections to the schematic
2016-01-10 Schematic is now almost complete. An error with DCDC converter power output ports must be fixed and input and output filtering capacitors must be added. Pdf schematic has also been generated.
2016-01-10 Fixed some of the power port problems, only one problem remains now.
2016-01-12 Added a few decoupling caps to schematic
2016-02-27 The Readme file added.
2016-02-27 Created PositionControl and Readme file
2016-02-27 Added position calculation files
2016-02-27 Fixed following function
2016-02-28 Added Android Studio project
2016-02-28 Changed misc.xml
2016-02-28 Refactorisation of code
2016-02-28 Created PCB footprint for TEL3-1211 DC-DC converter. Fixed power output ERC error in the schematic.
2016-02-29 Fixed few calculation issues
2016-02-29 Added few debug printouts
2016-03-01 Bug fixing
2016-03-01 Added simple User Interface
2016-03-02 Added time component to calculations
2016-03-02 Time offsets are added due to turning Earth over its own axis and turning around the sun
2016-03-03 Code refactorisation
2016-03-04 Implementation of MOVE command
2016-03-04 Added fine tunning the telescope movement
2016-03-05 Tracing mode updated with 2 new messages.
2016-03-06 First running application
2016-03-06 Added few classes
2016-03-07 Android: Implementation of Telescope Position calculation
2016-03-07 Added move method
2016-03-07 Added Java Tutorial
2016-03-08 Android: Added time component
2016-03-08 Added GPS tracker Class
2016-03-08 Added permissions for GPS provider
2016-03-09 Android: Fixed several bugs. Code refactorisation
2016-03-09 Android: Added classes for BlueTooth service
2016-03-10 Android: Implementation of BlueTooth service
2016-03-10 Android: Started with message processing
2016-03-11 Android: Implemented Trace thread. Updated Control
2016-03-11 Android: Added simple Message processing emulator
2016-03-11 Android: Added debug Emulator for Arduino
2016-03-12 Fixed few bugs on multythreading
2016-03-12 Android: Added button widgets
2016-03-13 Android: Fixed Trace on/Trace off actions.
2016-03-13 Android: Updated GUI.
2016-03-14 Android: Added simple Arduino emulator, for BT testing
2016-03-15 Android: Created Server/Client BlueTooth connection
2016-03-15 Android: Fixed few bugs in BlueTooth service
2016-03-15 Android: Implemented message listener from Arduino
2016-03-17 Android: Fixed several bugs
2016-03-20 Android: Implementation of few more messages
2016-03-21 Android: Fixed bug in Message for Battery Voltage
2016-03-21 Android: Fixed bug in GPS service
2016-03-23 Android: Few changes in Layout
2016-03-23 Android: Few layout changes
2016-03-24 Android: Implemented warning messages, alarms.
2016-03-28 Android: GUI changes
2016-03-28 Fixed TEL3-1211 footprint and removed old text from schematic.
2016-03-31 Android: Added drawing view layout. The height and azimuth are represented graphically.
2016-04-12 Android: Bug fixing and status state machine implementation
2016-04-21 Android: Fixed few bugs in calculation. Refactorisation. Add few new messages
2016-04-24 Added Arduino sketchbook
2016-04-28 Added document which describes Moonstalker-Arduino messages for communication
2016-05-01 Android: Added few Message Boxes. Fixed few bugs
2016-05-01 Android: Fixed reconnecting bug
2016-05-14 Android: Fixed few problems in position calculation
2016-05-15 Android: Tunning in RA, DEC to AZ, ALT transformations
2016-10-02 Removed ArduinoDebug class
2016-11-20 Added some more PCB stuff.
2016-12-31 Generated netlist and started associating symbols to footprints.
2016-12-31 Added footprints for Arduino Micro and Pololu DRV8825.
2017-01-07 Finished schematic, footprints and cvpcb associations. Netlist complete and ready for PCB layout.
2017-01-08 Started pcb layout. A lot of work already done.
2017-01-08 Finished all connections in the pcb layout. Still have to check all DRC rules, add OSHPark limits, make some tracks thicker.
2017-01-13 Adjusted all track widths and design rules for Osh Park. Mounting holes still missing.
2017-03-11 Added mounting holes and silkscreen logo to the PCB.
2017-03-12 Made the RefDes for mounting holes invisible.
2017-03-12 Moved some RefDes around, they were wrongly positioned. Generated files for manufacturing in gerbers directory.
2017-03-12 Added BOM.
2017-03-27 Added bluetooth settings file.
2017-03-28 Started working on Arduino code.
2017-03-29 Updated R1 and R2 resistor values to real measured values.
2018-03-03 Code refactorisation. Fixed few issues.
2018-03-03 Removed misc.xml generated file
2018-03-03 Refactorisation
2018-04-03 Refactorisation of code. Open GL included
2018-05-05 GUI Redesign
2018-05-05 Added new drawables
2018-07-22 Dialog is shown to prompt connecting to telescope.
2018-07-31 Framework change in AsyncTasks.
2018-08-01 Fixed few bugs and refactoring.
2018-08-08 Get list of constellations from web.
2019-01-08 Upgrade to API 28.
2019-02-26 Few files moved for gitignore
2019-02-27 Started Arduino SW implementation.
2019-02-28 Refactor, and fix few bugs.
2019-03-02 Arduino SW implemented further.
2019-03-02 More changes.
2019-03-03 Added port manipulation commands to set step pins high or low.
2019-03-03 Added pin initialization.
2019-03-03 Pulse generation working, tested horizontal direction.
2019-03-04 More functionality.
2019-03-06 Now using two timers.
2019-03-06 moonstalker v 2.0
2019-03-06 Telescope status is different class.
2019-03-06 Added stop command and some changes to pulse timing selection.
2019-03-07 Fixed a bug where the current step was not initialized to zero for horizontal and vertical. Added printout for the initial ocrxa values.
2019-03-07 Few bug-fixes.
2019-03-07 Refactorisation of Messages/OP codes
2019-03-07 Refactorisation.
2019-03-07 Fixed port bits for vertical.
2019-03-08 Implementation of status state machine.
2019-03-08 Implementation of manual control fragment.
2019-03-10 Implementation of move fragment.
2019-03-10 Moved serial to bluetooth. Added ignoring of CR characters over serial.
2019-03-10 Fixed battery voltage calculation.
2019-03-13 MOVE message process.
2019-03-19 Predelava status state machine.
2019-03-19 Odstranjen spinner za ozvezdja.
2019-03-24 Stepper data saved into documuntation.
2019-03-25 Izdelava GUI.
2019-03-25 Implementation of manual control.
2019-04-02 Implementacija rocnega vodenja teleskopa.
2019-04-04 Implementacija 'premakni na'.
2019-04-04 APKs for MoonStalker and Arduino Emulator
2019-04-05 Implementacija 'sledenje'.
2019-04-05 APKs
2019-04-05 gradle config and gitignore
2019-04-05 updated messages documentation
2019-04-05 format izpisa H in A
2019-04-06 Nekaj sprememb v GUI
2019-04-06 Integracija
2019-04-06 new moonstalker.apk
2019-04-06 Updated message documents.
2019-04-06 Removed mv text from battery voltage report.
2019-04-06 debbuging apk
2019-04-06 Spinner za ozvezdja.
2019-04-07 Integracija s HW. messages...
2019-04-07 Integracija s: HW. messages...
2019-04-07 new apk: popravki pri parsanju vhodnih messagev, zdej bi mogl delat
2019-04-07 Implementacija NOT_READY in MV_ACK.
2019-04-07 Settings fragment...
2019-04-07 nov APK: Format instrukcije je MV a b, namesto MV a,b
2019-04-07 apk s popravljenim formatom za MV
2019-04-07 Added info messages to the message document. Added responses to MVS and MVE commands.
2019-04-07 settings fragment
2019-04-19 nastavitve
2019-04-22 fragment monitoring
2019-04-22 merged to master
2019-04-22 merging
2019-04-22 izdelava monitoring fragmenta
2019-04-26 predelava
2019-04-28 preda k zada
2019-04-29 GUI predelan
2019-05-06 Fix in arduino emulator for voltage.
2019-05-06 Arduino emulator build.gradle.
2019-05-06 encodings for arduino emulator
2019-05-06 project changes for arduino emulator
2019-05-06 Upgreaded framework.
2019-05-06 apk v1.22
2019-07-21 Modifying Drive SW. Adding class StepperController.
2019-07-21 Changed names and updated code for Drive. Modified messages document.
2019-07-21 Implemented new functionality in the main .ino file.
2019-07-22 More changes to Drive.
2019-07-23 Fixed the register value calculation.
2019-09-23 deleted previous version of moonstalker
2019-09-23 Verzija 3.0
2019-09-23 Removed
2019-09-24 Version 3.0
2019-09-24 gitignore
2019-09-24 Migration to Canary Android studio
2019-12-08 First files for Moonstalker Server project.
2020-01-17 server implementation
2020-01-17 Refactor
2020-01-18 Fixes in state machine
2020-01-19 Fixed option for disconnect
2020-01-23 Fixed stuck option in states. Opcija ki preverja ce se v XY stanju zacikla.
2020-01-24 Popravil manual control ter dodal MVS acknowledge.
2020-01-25 Nekaj popravkov/optimizacije
2020-01-26 Zimplementiral MOVE END.
2020-01-30 Zimplementiral komade pri premikanju.
2020-02-02 Updated UI.
2020-02-08 Dodana knjisnica za vektorsko grafiko SVG.
2020-02-20 Dodana knjiznica za vektorsko grafiko SVG.
2020-02-23 Dodana knjiznica za vektorsko grafiko SVG. SVGResources fix.
2020-04-26 TB6600 data sheet added.
2020-04-28 Added test sketch for stepper motors.
2020-04-29 Test sketch for Control updated.
2020-05-09 Refactorisation of code.
2020-05-10 Puscice delujejo, ko jih kliknes.
2020-06-07 Manual fragment - izdelava.
2020-06-30 Fixed problems.
2020-06-30 Migration to Android Studio 4.0
2020-07-01 Refactor.
2020-07-03 Position string updated.
2020-08-28 Upgraded to higher version of Android studio
2021-12-26 Upgraded to higher version of Android studio.
2021-12-28 Build environment refacts.
2022-04-03 Emulator, refactorisation.
2022-04-03 Refactorisations
2022-05-01 Started version 2.0
2022-05-28 Started version 2.0. Bluetooth refactorisation.
2022-05-28 Started version 2.0. State machine refactorization.
2022-05-28 Started version 2.0. Added math library
2022-05-28 Started version 2.0.
2022-05-28 Started version 2.0. Introduced snack bar.
2022-05-29 Started version 2.0. Removed some packages.
2022-06-09 Started version 2.0. Refactorization.
2024-01-02 system update
2024-03-09 Changes for 3.0 version
2026-06-03 Generated a lot of new code with AI
2026-06-05 Added limit switch support
2026-06-07 Added free run ramp up and down
2026-06-15 Agent refactorisation.
2026-06-15 UI-UX refactorisation.
2026-06-16 Beautify
2026-06-17 Changed rest login functionality.
2026-06-25 - Added commands_doc.txt, generated docs with the description of all commands accepted by the drive software, all the parameters and responses generated. - Moved from Serial1 interface that was used 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
2026-06-25 Adding testing gui for sending commands to arduino
2026-06-25 Changed rest login functionality. It affects all other commands.
2026-06-27 -Remodelled GUI -Added requirements.txt -Added .exe file for Windows
